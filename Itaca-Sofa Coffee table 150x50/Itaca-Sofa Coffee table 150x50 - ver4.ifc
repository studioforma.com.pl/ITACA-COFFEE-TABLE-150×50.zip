Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Itaca-Sofa Coffee table 150x50 - ver4.ifc
Time: 2025-11-13T17:55:43
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (8)
Name
 | Itaca-Sofa Coffee table 150x50_0 - ObjectType: SketchupGroup
 | Itaca-Sofa Coffee table 150x50_1 - ObjectType: SketchupGroup
 | Itaca-Sofa Coffee table 150x50_2 - ObjectType: SketchupGroup
 | Itaca-Sofa Coffee table 150x50_3 - ObjectType: SketchupGroup
 | Itaca-Sofa Coffee table 150x50_4 - ObjectType: SketchupGroup
 | Itaca-Sofa Coffee table 150x50_5 - ObjectType: SketchupGroup
 | Itaca-Sofa Coffee table 150x50_6 - ObjectType: SketchupGroup
 | Itaca-Sofa Coffee table 150x50_7 - ObjectType: SketchupGroup
